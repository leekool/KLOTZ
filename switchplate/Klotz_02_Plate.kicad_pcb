File: switchplate/Klotz_02_Plate.kicad_pcb (KiCad board)
At the start: 2 copper layers, 120.5 x 85.5 mm, 8 parts

Commit message: init
Other:
- outline, holes or cut-outs redrawn
